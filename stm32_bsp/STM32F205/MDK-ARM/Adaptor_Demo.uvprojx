# Keil uVision project Adaptor_Demo.uvprojx, settings and files
target Adaptor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Adaptor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx,USE_USB_FS,SERVER_ROLE
  c misc: --C99
  c include: ../Core/inc;../Config;../../Utilities/CPU;../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;..\..\Drivers\STM32F2xx_HAL_Driver\Inc;../../Drivers/BSP/Components/Common;../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../Middlewares/Third_Party/FatFs/src;../../Middlewares/Third_Party/FatFs/src/drivers;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Drivers\CMSIS\Include;..\..\..\System;..\..\..\Test;..\..\..\Storage;..\..\..\USB;..\..\..\Upgrade;..\..\..\Src;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC_CustomHID\inc
  asm include: ROJ_DIR$\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10
  memory RVCT10: RAM 0x20000010 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User/Core
    ../Core/Src/: main.c BoardBsp.c
    ../../../Src/: LCP_Port.c
  group Application/USB
    ../../../USB/: usbd_customhid_if.c usbd_desc.c usb_core.c usbd_storage.c usbd_msc_desc.c
    ../Config/: usbd_conf.c
  group Application/Storage
    ../../../Storage/: SPI_Mem.c Storage.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
    ../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hcd.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_ll_usb.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc.c
  group Drivers/BSP
    ../Core/Src/: stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_TIM.c stm32f2xx_it.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../../Middlewares/Third_Party/FatFs/src/drivers/: snor_diskio.c
  group Middlewares/STM32_USBD
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC_CustomHID/src/: usbd_msc_customhid.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c queue.c timers.c list.c tasks.c
  group Middlewares/FreeRTOS/Portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.0.0
